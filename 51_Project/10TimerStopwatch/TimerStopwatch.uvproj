# Keil uVision project TimerStopwatch.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TimerStopwatch +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Nixie.c Delay.c Nixie.h Delay.h
